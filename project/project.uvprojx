# Keil uVision project project.uvprojx, settings and files
target MicroFly (ARM-ADS)
  device: TM4C123FH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MicroFly
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123FH6PM TARGET_IS_BLIZZARD_RA1
  c include: applications;.;drivers;libraries;libraries\inc;libraries\driverlib;..\include;..\libcpu\arm\cortex-m4;..\libcpu\arm\common;..\components\dfs;..\components\dfs\include;..\components\dfs\filesystems\devfs;..\components\drivers\include;..\components\drivers\include;..\components\finsh;..\components\init;..\components\dfs\filesystems\elmfat;.\MicFly;.\utils;.\Math;.\MicFly_Control;.\RTT_Drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c board.c startup.c
    ./applications/: cpuusage.c log.c ssi_test.c
  group MicFly
    ./MicFly/: imu_api.c transfer_app.c stabilizer_app.c transfer_package_api.c communicate_app.c battery_app.c calibration_routines.c mag_calibration.c led_app.c
  group MicFly_Control
    ./MicFly_Control/: controller.c pid.c
  group RTT_Drivers
    ./RTT_Drivers/: rtt_tm4c_spi.c rtt_nrf24l01.c rtt_led.c rtt_battery.c
  group SensorLib
    ./sensorlib/: comp_dcm.c i2cm_drv.c mpu6050.c mpu9150.c quaternion.c vector.c ak8975.c
  group Drivers
    drivers/: drv_uart.c sdcard.c
    ./drivers/: nRF24L01.c PWM_Out.c battery.c drv_eeprom.c
  group utils
    ./utils/: filter.c
  group Libraries
    libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ./libraries/startup/: startup_rvmdk.S
  group Kernel
    ../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../components/dfs/filesystems/elmfat/option/: ccfile.c
    ../components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    ../components/drivers/serial/: serial.c
    ../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../components/drivers/spi/: spi_core.c spi_dev.c
  group finsh
    ../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../components/init/: components.c
