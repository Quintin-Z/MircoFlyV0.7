# Keil uVision project template.uvproj, settings and files
target MicroFly (ARM-ADS)
  device: TM4C123FH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MicroFly
  c flags: Optim=1 wLevel=2
  c define: TARGET_IS_BLIZZARD_RA1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
